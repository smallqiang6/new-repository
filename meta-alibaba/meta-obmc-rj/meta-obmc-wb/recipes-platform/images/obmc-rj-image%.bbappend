
# Include modules in rootfs
IMAGE_INSTALL += " \
  dfd-debug \
  firmware-upgrade \
  wb-platform \
  rtk-phy \
  scan-asdsmc \
  "
