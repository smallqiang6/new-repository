FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://passwd-util.service \
          "
