FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
        file://hostname.sh \
"
